# Keil uVision project TEST1.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TEST1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.5.0, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL 1.11.0, Device:Startup 2.3.3
