# Keil uVision project System_Test.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: System_Test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: ..\System_Test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c MDMA_program.c ADC_program.c GPIO_program.c NVIC_program.c PWM_program.c RCC_program.c USART_program.c STK_Program.c MI2C_program.c ENCODER_program.c Temp_program.c HIMU_program.c EXTI_program.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
