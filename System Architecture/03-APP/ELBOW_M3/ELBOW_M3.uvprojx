# Keil uVision project ELBOW_M3.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ELBOW_M3 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: DC_motor.c DMA_program.c ENCODER_program.c GPIO_program.c NVIC_program.c PWM_program.c RCC_program.c Servo_program.c STK_Program.c USART_program.c main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
