# Keil uVision project PALM_APP_M3.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PALM_APP_M3
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: ADC_program.c DC_motor.c GPIO_program.c NVIC_program.c PID_program.c POT_program.c PWM_program.c RCC_program.c Servo_program.c STK_Program.c main.c APP_Palm_Functions.h FSR_Program.c F_MLX96014.c F_SMBUS.c DMA_program.c USART_program.c AFIO_program.c HIMU_program.c MI2C_program.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
